# Keil uVision project STM32_CGMCU.uvprojx, settings and files
target DHT11 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_CGMCU
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\HARDWARE\DHT11;..\HARDWARE\LED;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\GM_ADC;..\HARDWARE\MFRC522;..\HARDWARE\MyOLED;..\SYSTEM\adc;..\HARDWARE\RFID;..\HARDWARE\DHT11;..\HARDWARE\HUNMAN;..\HARDWARE\WIFI;..\SYSTEM\time;..\HARDWARE\PWM;..\HARDWARE\KEY;..\HARDWARE\buzzer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/MFRC522/: MFRC522.c
    ../HARDWARE/MyOLED/: OLED.c
    ../HARDWARE/RFID/: RFID.c
    ../HARDWARE/DHT11/: DHT11.c
    ../HARDWARE/HUNMAN/: human.c
    ../HARDWARE/WIFI/: wifi.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/buzzer/: buzzer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/adc/: adcx.c
    ../SYSTEM/time/: time.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_tim.c
